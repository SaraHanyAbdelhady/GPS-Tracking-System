# Keil uVision project GPS-Tracking-System.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: GPS-Tracking-System
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: startup_TM4C123.s system_TM4C123.c
  group src
    ./src/APP/: Main.c APP.c
    ./src/MCAL/UART/: UART.c
    ./src/MCAL/GPIO/: GPIO.c
    ./src/MCAL/SYSTICK/: Systick.c
    ./src/HAL/GPS/: GPS.c
    ./src/HAL/LED/: LED.c
    ./src/HAL/Push Button/: Push button.c
    ./src/HAL/LCD/: LCD.c
    ./src/MCAL/EEPROM/: EEPROM.c
  group Headers
    ./Headers/MCAL/UART/: UART.h
    ./Headers/MCAL/SYSTICK/: Systick.h
    ./Headers/HAL/GPS/: GPS.h
    ./Headers/HAL/LED/: LED.h
    ./Headers/HAL/Push Button/: Push button.h
    ./Headers/HAL/LCD/: LCD.h
    ./Headers/MCAL/GPIO/: GPIO.h
    ./Headers/APP/: APP.h
    ./Headers/MCAL/EEPROM/: EEPROM.h
  group Services
    ./Services/: Bit_Utilities.h STD_TYPES.h tm4c123gh6pm.h
